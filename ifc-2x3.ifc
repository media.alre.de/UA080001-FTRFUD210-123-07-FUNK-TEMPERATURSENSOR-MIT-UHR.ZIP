Properties of the parts of a building model (IFC2X3)

# File
Description: Funk-Raumtemperatursensor mit Uhr, UP, Abdeckung 50 x 50 mm, reinweiß, glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA080001, Funk-Raumtemperatursensor mit Uhr, UP, Abdeckung 50 x 50 mm, reinweiß, glänzend
In: Raum
Description: Funk-Sensoren für in Wohn-, Büro- und Hotelräumen üblichen Verschmutzungsgrad. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen. UP-Funk-Raumtemperatursensor zur Erfassung und Einstellung der Raumtemperatur mit Uhr. In Verwendung mit alre-Funk-Aktoren wird eine zeitgesteuerte Einzelraum-Temperaturregelung verwirklicht.; Classification: EC001101 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA080001; ModelLabel: FTRFUd210.123#07; GlobalTradeItemNumber: 4050528068859; ProductURL: https://alre.de/produkt_UA080001
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.046 m; NetWeight: 0.122
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Zusammenstellung: Basiselement mit zentraler Abdeckplatte; Farbe: weiß; Oberflächenschutz: unbehandelt; Mit Display: yes; Werkstoffgüte: Thermoplast; Bussystem Funkbus: yes; Mit Busankopplung: yes; Werkstoff: Kunststoff; Mit Diebstahl-/Demontageschutz: no; Manuelle Sollwertverstellung: yes; RAL-Nummer (ähnlich): 9010; Schutzart (IP): IP30; Mit LED-Anzeige: no; Ausführung der Oberfläche: glänzend; Mit Vor-Ort Bedienung: yes; Funk bidirektional: no; Bussystem KNX Secure: no; Bussystem KNX Secure-RF (Funk): no; ETIM-Klasse: EC001101; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA080001.pdf
